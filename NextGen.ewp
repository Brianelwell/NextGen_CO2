# IAR project NextGen.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32C031C6 ST STM32C031C6
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; HSI_VALUE=48000000; VDD_VALUE=3300; PREFETCH_ENABLE=0; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1; STM32C011xx
  ICCARM.CCIncludePath2: inc; inc\Processor
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: NextGen.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/EWARM
    EWARM/: startup_stm32c031xx.s
  group Application/User/inc
    inc/: adc.h common.h flash.h gas_daq.h gpio.h i2c.h main.h pwm.h T68xx.h usart.h
  group Application/User/src
    src/: adc.c common.c flash.c gas_daq.c gpio.c i2c.c main.c pwm.c usart.c
  group Drivers/STM32C0xx_HAL_Driver/inc
    inc/Processor/: stm32_assert.h stm32c011xx.h stm32c031xx.h stm32c0xx.h stm32c0xx_ll_adc.h stm32c0xx_ll_gpio.h stm32c0xx_ll_i2c.h stm32c0xx_ll_iwdg.h stm32c0xx_ll_rcc.h stm32c0xx_ll_tim.h stm32c0xx_ll_usart.h stm32c0xx_ll_utils.h
  group Drivers/STM32C0xx_HAL_Driver/src
    src/Processor/: stm32c0xx_it.c stm32c0xx_ll_adc.c stm32c0xx_ll_gpio.c stm32c0xx_ll_i2c.c stm32c0xx_ll_rcc.c stm32c0xx_ll_tim.c stm32c0xx_ll_usart.c stm32c0xx_ll_utils.c system_stm32c0xx.c
